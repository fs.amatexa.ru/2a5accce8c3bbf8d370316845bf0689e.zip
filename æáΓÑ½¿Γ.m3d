# KOMPAS-3D part (æáΓÑ½¿Γ.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 8
3. Фаска:1
     Угол = 45; Длина 1 = 0.5; Длина 2 = 0.5
